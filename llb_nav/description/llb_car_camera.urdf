Commit message: align

File: llb_nav/description/llb_car_camera.urdf (robot description, URDF)
Before this commit: robot llb_car, 7 links, 6 joints
Joints:
- joint joint_base_wheel1: type revolute -> fixed
- joint joint_base_wheel2: type continuous -> fixed
