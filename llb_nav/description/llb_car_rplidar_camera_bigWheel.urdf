Commit message: align

File: llb_nav/description/llb_car_rplidar_camera_bigWheel.urdf (robot description, URDF)
Before this commit: robot llb_car, 9 links, 8 joints
Joints:
- joint joint_base_wheel1: type revolute -> fixed
- joint joint_base_wheel2: type revolute -> fixed
